require recipes-fsl/images/fsl-image-machine-test.bb 

# Open CV related Stuff
CORE_IMAGE_EXTRA_INSTALL += "opencv opencv-samples"
